## apps/blinky/app/Kconfig
```kconfig
menu "Zephyr"
source "Kconfig.zephyr"
endmenu

module = QPC
module-str = QPC
source "subsys/logging/Kconfig.template.log_config"
```
